# Keil uVision project 103c8_freeRTOS.uvprojx, settings and files
target 103c8_freeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 103c8_freeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\freeRTOS\port\ARM_CM3;..\Library\CMSIS;..\Library\FWlib\inc;..\User;..\User\Key;..\User\led;..\User\usart;..\..\..\..\elab\3rd\FreeRTOS\include;..\config;..\..\..\..\elab\os\mcu_os;..\..\..\..\elab\os;..\..\..\..\elab\common;..\Bsp;..\..\..\..\elab\edf\normal;..\..\..\..\elab\edf;..\Driver;..\export;..\Device;..\..\..\..\elab\edf\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group freeRTOS/port
    ../freeRTOS/port/MemMang/: heap_4.c
    ../freeRTOS/port/ARM_CM3/: port.c
  group CMSIS
    ../Library/CMSIS/startup/: startup_stm32f10x_md.s
    ../Library/CMSIS/: system_stm32f10x.c core_cm3.c
  group FWLIB
    ../Library/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/Key/: bsp_key.c
  group BSP
    ../Bsp/: bsp_usart.c bsp_dwt.c
  group DRIVER
    ../Driver/: driver_pin_mcu.c drv_util.c
  group DEVICE
    ../Device/: elab_led_adapter.c
  group export
    ../export/: device_export.c pin_export.c
  group elab/3rd/freertos
    ../../../../elab/3rd/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group elab/os/cmsis
    ../../../../elab/os/mcu_os/: cmsis_os2.c
  group elab/edf
    ../../../../elab/edf/: elab_device.c elab_device_null.c
    ../../../../elab/edf/normal/: elab_pin.c
    ../../../../elab/edf/user/: elab_led.c
  group elab/common
    ../../../../elab/common/: elab_assert.c elab_common.c elab_export.c elab_log.c
  group config
    ../config/: FreeRTOSConfig.h elab_config.h
